# Keil uVision project NEXTGEN_E-NOTICE_SECURE_GSM_BASED_DYNAMIC_DISPLAY_SYSTEM.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 2 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s delay.c gsm.c i2c.c i2c_eeprom.c uart.c security.c sipo_74hc164.c dotmatrix.c main4.c
